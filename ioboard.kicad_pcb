# Repository B0rgar/MFOS-VCA

File README.md:

Ray Wilsons VCA with panel. based on Eagleproject from Gerbster.nl.

imported to kicad. 
IO board redesigned for thonkicons jacks. 
increased distance between boards and changed the nibbles
panel made.

PCBS ordered from JLCPCB. will update after building and testing.

## KiCad design ioboard.kicad_pcb

Parts:
AUDIO_IN_1, AUDIO_IN_2: PJ301BMPJ301BM; PJ301BM
AUDIO_OUT_1, AUDIO_OUT_2: PJ301BMPJ301BM; PJ301BM
BIAS_1, BIAS_2: 100k; EVUF
C1, C2, C3, C4: .1uf; C050-024X044
C6, C7: 10uf; E2,5-5
CV1_1, CV1_2, CV2_1, CV2_2: PJ301BMPJ301BM; PJ301BM
CV_ATTN_1, CV_ATTN_2: 50k; EVUF
IC1: TL074P; DIL14
IC2: LM13700N; DIL16
JP1, JP2, JP3, JP4: PINHD-1X6; 1X06
JP5, JP6: PINHD-1X4; 1X04
PWR0: ML10
Q1, Q3: 2N3904; TO92
Q2, Q4: 2N3906; TO92
R1, R2: 100k; S64YW
R3, R4: 2k; S64YW
R5, R6: 2M; 0204_7
R7, R27: 150R; 0204_7
R8, R14, R16, R17, R18, R22, R23, R28, R34, R36, R37, R38, R42, R43: 100k; 0204_7
R9, R29: 470k; 0204_7
R10, R30: 47k; 0204_7
R11, R31: 1k; 0204_7
R12, R32: 4.7k; 0204_7
R13, R15, R21, R33, R35, R41: 2k; 0204_7
R19, R39: 120k; 0204_7
R20, R26, R40, R46: 20k; 0204_7
R24, R44: 470R; 0204_7
R25, R45: 30k; 0204_7
S1, S2: M9040P

Connections:
+12V: BIAS_1.3 (E), BIAS_2.3 (E), C2.1, C3.1, C7.+, IC1.4 (V+), IC2.11 (V+), JP5.2, JP6.3, PWR0.1, PWR0.2, Q1.1 (C), Q3.1 (C), R1.E, R2.E, R9.1, R14.1, R23.1, R29.1, R34.1, R43.1
-12V: BIAS_1.1 (A), BIAS_2.1 (A), C1.1, C4.1, C6.-, IC1.11 (V-), IC2.6 (V-), JP5.3, JP6.2, PWR0.9, PWR0.10, R1.A, R2.A, R12.1, R19.1, R26.1, R32.1, R39.1, R46.1
AI1_IO: AUDIO_IN_1.TIP (3), JP2.2
AI1_M: JP3.5, R8.1
AI2_IO: AUDIO_IN_2.TIP (3), JP1.2
AI2_M: JP4.5, R28.1
AO1_IO: AUDIO_OUT_1.TIP (3), JP2.6
AO1_M: JP3.1, R11.2
AO2_IO: AUDIO_OUT_2.TIP (3), JP1.6
AO2_M: JP4.1, R31.2
CV1_IO: JP2.1, R16.2, R17.2, R18.2
CV1_M: IC1.2 (-IN), JP3.6, R13.1
CV2_IO: JP1.1, R36.2, R37.2, R38.2
CV2_M: IC1.13 (-IN), JP4.6, R33.1
GND: AUDIO_IN_1.GND, AUDIO_IN_1.GND1 (5), AUDIO_IN_1.GND2 (5), AUDIO_IN_2.GND, AUDIO_IN_2.GND1 (5), AUDIO_IN_2.GND2 (5), AUDIO_OUT_1.GND, AUDIO_OUT_1.GND1 (5), AUDIO_OUT_1.GND2 (5), AUDIO_OUT_2.GND, AUDIO_OUT_2.GND1 (5), AUDIO_OUT_2.GND2 (5), C1.2, C2.2, C3.2, C4.2, C6.+, C7.-, CV1_1.GND, CV1_1.GND1 (5), CV1_1.GND2 (5), CV1_2.GND, CV1_2.GND1 (5), CV1_2.GND2 (5), CV2_1.GND, CV2_1.GND1 (5), CV2_1.GND2 (5), CV2_2.GND, CV2_2.GND1 (5), CV2_2.GND2 (5), CV_ATTN_1.3 (E), CV_ATTN_2.3 (E), IC2.4 (-IN), IC2.13 (-IN), JP5.1, JP5.4, JP6.1, JP6.4, PWR0.3, PWR0.4, PWR0.5, PWR0.6, PWR0.7, PWR0.8, Q2.3 (E), Q4.3 (E), R7.1, R10.2, R15.2, R24.2, R27.1, R30.2, R35.2, R44.2
IO_CV1: CV_ATTN_1.1 (A), R18.1
IO_CV2: CV_ATTN_2.1 (A), R38.1
unnamed: R2.S, R6.1
unnamed: R3.A, R7.2
unnamed: IC2.3 (+IN), R3.E, R3.S, R8.2
unnamed: IC2.5 (OUT), IC2.7 (IN), R6.2, R9.2, R10.1
unnamed: R4.A, R27.2
unnamed: IC2.8 (OUT), R11.1, R12.2
unnamed: BIAS_1.2 (S), R17.1
unnamed: IC1.1 (OUT), Q1.2 (B), R13.2, R21.1
unnamed: IC1.3 (+IN), R14.2, R15.1
unnamed: IC1.5 (+IN), R23.2, R24.1
unnamed: CV2_1.TIP (3), R16.1
unnamed: Q1.3 (E), Q2.2 (B), R19.2
unnamed: R1.S, R5.1
unnamed: Q2.1 (C), R20.2
unnamed: IC1.6 (-IN), R21.2, R22.1
unnamed: IC1.7 (OUT), R22.2, R25.2
unnamed: IC2.14 (+IN), R4.E, R4.S, R28.2
unnamed: IC2.10 (IN), IC2.12 (OUT), R5.2, R29.2, R30.1
unnamed: IC2.9 (OUT), R31.1, R32.2
unnamed: IC1.14 (OUT), Q3.2 (B), R33.2, R41.1
unnamed: IC1.12 (+IN), R34.2, R35.1
unnamed: Q3.3 (E), Q4.2 (B), R39.2
unnamed: Q4.1 (C), R40.2
unnamed: IC1.9 (-IN), R41.2, R42.1
unnamed: IC1.8 (OUT), R42.2, R45.2
unnamed: IC1.10 (+IN), R43.2, R44.1
unnamed: CV1_1.TIP (3), CV_ATTN_1.2 (S)
unnamed: CV1_2.TIP (3), CV_ATTN_2.2 (S)
unnamed: BIAS_2.2 (S), R37.1
unnamed: CV2_2.TIP (3), R36.1
SWA1_IO: JP2.3, S1.1 (O)
SWA1_M: JP3.4, R20.1
SWA2_IO: JP1.3, S2.1 (O)
SWA2_M: JP4.4, R40.1
SWB1_IO: JP2.4, S1.2
SWB1_M: IC2.1 (IABC), JP3.3
SWB2_IO: JP1.4, S2.2
SWB2_M: IC2.16 (IABC), JP4.3
SWC1_IO: JP2.5, S1.3 (S)
SWC1_M: JP3.2, R25.1, R26.2
SWC2_IO: JP1.5, S2.3 (S)
SWC2_M: JP4.2, R45.1, R46.2

Board: 2 copper layers, 72.2 x 107.9 mm, 87 parts (0 on the bottom side), 59 nets.

Other parts of the board:
@HOLE0, @HOLE1, @HOLE2, @HOLE2#2, @HOLE2#3, @HOLE4, @HOLE4#2, @HOLE4#3: (no value)

## Commit log

2025-03-18 expanded cut
2025-03-18 pics
2025-03-18 board distance adjust
